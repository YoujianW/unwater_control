# Keil uVision project unwater_control.uvprojx, settings and files
target unwater_control (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F403AVGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.9
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: unwater_control +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F403AVGT7, USE_STDPERIPH_DRIVER, ARM_MATH_CM4, ARM_MATH_MATRIX_CHECK, ARM_MATH_ROUNDING, ARM_MATH_LOOPUNROLL, AT_START_F403A_V1, LV_CONF_INCLUDE_SIMPLE
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\ace_robot_kit\APP\app_config;..\..\ace_robot_kit\APP\app_task;..\..\ace_robot_kit\BSP\inc;..\..\ace_robot_kit\Component\led;..\..\ace_robot_kit\Component\time;..\..\ace_robot_kit\Component\vofa;..\..\ace_robot_kit\Component\sbus;..\..\ace_robot_kit\Component\Common\Filter;..\..\ace_robot_kit\Component\Common\Input_event;..\..\ace_robot_kit\Third_party\MultiButton;..\..\ace_robot_kit\Third_party\MultiTimer;..\..\ace_robot_kit\Component\Common\circle_queue;..\..\ace_robot_kit\Component\Common\user_lib;..\..\ace_robot_kit\Component\button;..\..\middlewares\freertos\source;..\..\ace_robot_kit\Component\mpu6050;..\..\ace_robot_kit\Component\w25q16;..\..\ace_robot_kit\Component\oled;..\..\ace_robot_kit\Component\st7789;../../libraries/cmsis/dsp/include;../../libraries/cmsis/dsp/PrivateInclude;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/rvds/ARM_CM4F;..\..\ace_robot_kit\Third_party\lvgl
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c freertos_app.c include_port.c wk_adc.c wk_debug.c wk_usart.c wk_dma.c wk_tmr.c wk_gpio.c wk_i2c.c wk_spi.c wk_pwc.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_tmr.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_usart.c at32f403a_407_pwc.c at32f403a_407_adc.c at32f403a_407_spi.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_exint.c at32f403a_407_misc.c at32f403a_407_debug.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group cmsis_dsp
    ../../libraries/cmsis/dsp/Source/BasicMathFunctions/: BasicMathFunctions.c
    ../../libraries/cmsis/dsp/Source/BayesFunctions/: BayesFunctions.c
    ../../libraries/cmsis/dsp/Source/CommonTables/: CommonTables.c
    ../../libraries/cmsis/dsp/Source/ComplexMathFunctions/: ComplexMathFunctions.c
    ../../libraries/cmsis/dsp/Source/ControllerFunctions/: ControllerFunctions.c
    ../../libraries/cmsis/dsp/Source/DistanceFunctions/: DistanceFunctions.c
    ../../libraries/cmsis/dsp/Source/FastMathFunctions/: FastMathFunctions.c
    ../../libraries/cmsis/dsp/Source/FilteringFunctions/: FilteringFunctions.c
    ../../libraries/cmsis/dsp/Source/InterpolationFunctions/: InterpolationFunctions.c
    ../../libraries/cmsis/dsp/Source/MatrixFunctions/: MatrixFunctions.c
    ../../libraries/cmsis/dsp/Source/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../../libraries/cmsis/dsp/Source/StatisticsFunctions/: StatisticsFunctions.c
    ../../libraries/cmsis/dsp/Source/SupportFunctions/: SupportFunctions.c
    ../../libraries/cmsis/dsp/Source/SVMFunctions/: SVMFunctions.c
    ../../libraries/cmsis/dsp/Source/TransformFunctions/: TransformFunctions.c
  group ace_robot_kit/APP
    ../../ace_robot_kit/APP/app_task/: app_lcd_task.c app_oled_task.c app_spi_task.c app_i2c_task.c app_vofa_task.c app_sbus_task.c app_button_task.c app_adc_task.c app_debug_task.c app_task.c app_low_pwc_task.c
    ../../ace_robot_kit/APP/app_config/: app_config.c
  group ace_robot_kit/BSP
    ../../ace_robot_kit/BSP/src/: bsp_pwc.c bsp_spi.c bsp_software_i2c.c bsp_i2c.c bsp_adc.c bsp_flash.c bsp_tmr_capture.c bsp_usart.c
  group ace_robot_kit/Component
    ../../ace_robot_kit/Component/sbus/: sbus.c
    ../../ace_robot_kit/Component/oled/: oled.c
    ../../ace_robot_kit/Component/st7789/: st7789.c
    ../../ace_robot_kit/Component/w25q16/: w25q16.c
    ../../ace_robot_kit/Component/mpu6050/: mpu_6050_software_i2c.c mpu6050.c
    ../../ace_robot_kit/Component/button/: button.c
    ../../ace_robot_kit/Component/Common/circle_queue/: circle_queue.c
    ../../ace_robot_kit/Component/Common/Filter/: Filter.c
    ../../ace_robot_kit/Component/Common/Input_event/: Input_event.c
    ../../ace_robot_kit/Component/Common/user_lib/: user_lib.c
    ../../ace_robot_kit/Component/led/: led.c
    ../../ace_robot_kit/Component/time/: time_core.c
    ../../ace_robot_kit/Component/vofa/: vofa.c
    ../../ace_robot_kit/Component/Common/crc_check/: crc_check.c
  group ace_robot_kit/Third_party
    ../../ace_robot_kit/Third_party/MultiButton/: multi_button.c
    ../../ace_robot_kit/Third_party/MultiTimer/: MultiTimer.c
  group ace_robot_kit/Third_party/lvgl
    ../../ace_robot_kit/Third_party/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev_scroll.c lv_indev.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style_gen.c lv_obj_style.c lv_obj_tree.c lv_obj.c lv_refr.c lv_theme.c
    ../../ace_robot_kit/Third_party/lvgl/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../ace_robot_kit/Third_party/lvgl/src/draw/: lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_draw.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../ace_robot_kit/Third_party/lvgl/src/draw/nxp/pxp/: lv_draw_pxp_blend.c lv_draw_pxp.c lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp.c
    ../../ace_robot_kit/Third_party/lvgl/src/draw/nxp/vglite/: lv_draw_vglite_arc.c lv_draw_vglite_blend.c lv_draw_vglite_line.c lv_draw_vglite_rect.c lv_draw_vglite.c lv_vglite_buf.c lv_vglite_utils.c
    ../../ace_robot_kit/Third_party/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c
    ../../ace_robot_kit/Third_party/lvgl/src/draw/sdl/: lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c lv_draw_sdl.c
    ../../ace_robot_kit/Third_party/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../ace_robot_kit/Third_party/lvgl/src/draw/sw/: lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c lv_draw_sw.c
    ../../ace_robot_kit/Third_party/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/: lv_extra.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/others/fragment/: lv_fragment_manager.c lv_fragment.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/others/msg/: lv_msg.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/led/: lv_led.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/list/: lv_list.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/span/: lv_span.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../../ace_robot_kit/Third_party/lvgl/src/extra/widgets/win/: lv_win.c
    ../../ace_robot_kit/Third_party/lvgl/src/font/: lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_10.c lv_font_montserrat_12_subpx.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28_compressed.c lv_font_montserrat_28.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_font.c
    ../../ace_robot_kit/Third_party/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../ace_robot_kit/Third_party/lvgl/src/misc/: lv_anim_timeline.c lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style_gen.c lv_style.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt_ap.c lv_txt.c lv_utils.c
    ../../ace_robot_kit/Third_party/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
